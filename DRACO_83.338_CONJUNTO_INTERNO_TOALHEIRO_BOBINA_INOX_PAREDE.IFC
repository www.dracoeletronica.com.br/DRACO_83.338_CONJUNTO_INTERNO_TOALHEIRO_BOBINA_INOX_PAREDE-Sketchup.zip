Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_83.338_CONJUNTO_INTERNO_TOALHEIRO_BOBINA_INOX_PAREDE.IFC
Time: 2022-12-21T17:29:12
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
